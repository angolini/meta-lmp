# Linux microPlatform extensions to the upstream OE-core kernel-fitimage class

INITRAMFS_IMAGE_BUNDLE = "0"

inherit kernel-fitimage
